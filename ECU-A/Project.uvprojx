# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\FreeRtos;.\FreeRtos\inc;.\FreeRtos\port;.\FreeRtos\src;.\App;.\Bsp;.\Bsp\inc;.\Bsp\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group FreeRtos/inc
    ./FreeRtos/: FreeRTOSConfig.h
    ./FreeRtos/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRtos/src
    ./FreeRtos/src/: list.c queue.c tasks.c croutine.c event_groups.c stream_buffer.c timers.c
  group FreeRtos/port
    ./FreeRtos/port/: heap_4.c port.c
    ./FreeRtos/: freertos_hooks.c
  group App
    ./App/: app_cli.c app_cli.h app_bms_state.c app_bms_state.h app_event.c app_event.h app_flash_log.c app_flash_log.h app_sensor.c app_sensor.h app_fault_manager.c app_fault_manager.h app_fault_event.c app_fault_event.h app_health_monitor.c app_health_monitor.h app_rtos.c app_rtos.h app_can_service.c app_can_service.h
  group Bsp
    ./Bsp/: bsp_adc_dma.c bsp_adc_dma.h bsp_can.c bsp_can.h bsp_gpio.c bsp_gpio.h bsp_spi_flash.c bsp_spi_flash.h bsp_tim.c bsp_tim.h bsp_usart.c bsp_usart.h can_protocol.h bsp_buzzer.c bsp_buzzer.h
